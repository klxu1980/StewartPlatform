# Keil uVision project fsmc_indep.uvprojx, settings and files
target fsmc_indep (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fsmc_indep +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: .\include;.\STM32F1xx_HAL_Driver\Inc;.\STM32F1xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start_up
    ./: startup_stm32f103xe.s
  group main
    ./main/: main.c
  group driver
    ./driver/: fsmc.c led.c stm32f1xx_it.c system_clock.c system_stm32f1xx.c usart.c key.c wwdg.c exti.c robot_inv.c
  group fwlib
    ./STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_sram.c stm32f1xx_hal_gpio.c stm32f1xx_hal_usart.c stm32f1xx_hal_uart.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_wwdg.c stm32f1xx_hal_tim.c
  group RobotCtrl
    ./RobotCtrl/: AccSensor.cpp BasicCalc.cpp CtrlBoard.cpp CtrlSystem.cpp CubicTrace.cpp JuneBugCtrl.cpp MotionSimu.cpp Robot.cpp RobotBasic.cpp RobotComm.cpp RobotFKP.cpp RobotIKP.cpp RobotServo.cpp StableCtrl.cpp MotionTrack.cpp
    ./: CtrlInterface.cpp
software components: CMSIS:CORE 4.3.0
